Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2019-12-16T15:27:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 16 15:27:53 2019 * Host: DSBIRNE-RO-DE * Database: C:\Users\Dsbirne\AppData\Local\Temp\{3ABAA503-3535-4F42-8DA5-1BC7D26C89AF}\ifc * Database version: 5507 * Database creation date: Mon Dec 16 15:27:51 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 16 15:27:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 16 15:27:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcPump: ODM 5, HC_Heat Pump_MEPcontent_ATAG_ENERGION_ODM 4-5_NL-NL:ODM 5:1367927
In: V00
Type - Material: Color RGB 055-055-055, Color RGB 255-255-255, Color RGB 160-160-160, Color RGB 079-088-095
Type - Dimensions - Depth: 347 mm; Height: 756 mm; Hydronic Return Connection Diameter: 25.4 mm; Hydronic Supply Connection Diameter: 25.4 mm; Use Nominal Diameter: yes; Width: 1016 mm
Type - Electrical - Phase: 1; Voltage: 230 V
Type - Identity Data - Article Type: ODM 5; Base Family Version: 12.06; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: ATAG ENERGION Monobloc 5 KW Buitenunit, enkel fase; EMCS Version: 4.0; ETIM Article Class: EC001213; Family Version: 12.06; GLN: 8712423021662; Manufacturer: ATAG; Manufacturer URL: https://www.atagverwarming.nl/; MEPcontent Class: HEATPUMP; Model: ODM 5; OmniClass Number: 23.75.10.21; OmniClass Title: Heat Pumps; Revit Version: 2017; Type Name: ODM 5; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Dark Blue Grey: Color RGB 079-088-095; Grey: Color RGB 160-160-160; White: Color RGB 255-255-255
Type - Mechanical - Heating Power 0/35°C: 0 W
Type - Mechanical - Loads - Cooling Power: 0 W
Type - Other - Category: Mechanical Equipment; Distance Between Bars: 730 mm; Family Name: HC_Heat Pump_MEPcontent_ATAG_ENERGION_ODM 4-5_NL-NL; Floor Frame Position: 335 mm
Type - Text - Article Description: ATAG ENERGION Monobloc 5 KW Buitenunit, enkel fase; GTIN: 05414849803053; Manufacturer Art. No.: 3069661; Product Line: ENERGION
Pset_ManufacturerTypeInformation - Manufacturer: ATAG
Constraints - Offset: 0 mm
Dimensions - Area: 11.2229 m2; Volume: 0.242113 m3
Electrical - Power: 0 W
Identity Data - Mark: 4
Mechanical - System Classification: Hydronic Return,Hydronic Supply,Power
Mechanical - Flow - Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s
Other - Family: HC_Heat Pump_MEPcontent_ATAG_ENERGION_ODM 4-5_NL-NL: ODM 5; Family and Type: HC_Heat Pump_MEPcontent_ATAG_ENERGION_ODM 4-5_NL-NL: ODM 5; Floor Mounting Height: 0 mm; Floor Mounting Type: M_Bracket_MEPcontent_ATAG_ENERGION_Floor Mounting_NL-NL_Shared: Steunbalken 600 mm; Type: HC_Heat Pump_MEPcontent_ATAG_ENERGION_ODM 4-5_NL-NL: ODM 5; Type Id: HC_Heat Pump_MEPcontent_ATAG_ENERGION_ODM 4-5_NL-NL: ODM 5; Wall Mounting Type: M_Bracket_Suspended_F_MEPcontent_ATAG_ENERGION_Wall Mounting_NL-NL_Shared: Muurbeugels MS 213
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Floor Mounting: no; Service Space: no; Wall Mounting: no
